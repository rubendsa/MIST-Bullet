Commit message: Droptests

File: MIST_online_vis.urdf (robot description, URDF)
Before this commit: robot physics, 12 links, 11 joints
Links:
- link link0: geometry collision box size=0.7 0.7 1.4; visual box size=0.32 0.26 0.085
